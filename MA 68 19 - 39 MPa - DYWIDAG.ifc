Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 2e523751-a5b4-4349-840c-7f483001bb15, NumberOfSaves: 1], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
Time: 2023-11-15T11:53:44+01:00
Written by: ODA SDAI 24.3
Made in: Autodesk Revit 24.1.10.25 (DEU) - IFC 24.1.10.25

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Ebene:Ebene 1, Ebene 1
LongName: Ebene 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Ebene 1; sets with these values: 2

# IfcBuildingElementProxy: 94 00 1015 - ISO kopie:94 00 1015 - ISO kopie, 94 00 1015 - ISO kopie:94 00 1015 - ISO kopie:1:2719
In: Ebene 1
Pset_BuildingElementProxyCommon - Reference: 94 00 1015 - ISO kopie; sets with these values: 2
